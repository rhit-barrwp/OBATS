options:
  parameters:
    generate_options: qt_gui
    id: BFSKtx
    output_language: python
    title: BFSKtx
  states: {}

blocks:
- name: PacketSize
  id: variable
  parameters:
    value: '8'
  states: {}
- name: RF_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: Repeat
  id: variable
  parameters:
    value: int(samp_rate/bit_rate)
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: '8'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 2.49e9
  states: {}
- name: eye_offset
  id: variable
  parameters:
    value: '1800e-6'
  states: {}
- name: frequency_spread
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: lowfreq
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*3.14*100000
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '110'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: 2*3.14*lowfreq/sensitivity
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Repeat+int(eye_offset*samp_rate)
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 5*Repeat+int(eye_offset*samp_rate)
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 4*Repeat+int(eye_offset*samp_rate)
    type: float
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 2*Repeat+int(eye_offset*samp_rate)
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 3*Repeat+int(eye_offset*samp_rate)
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 6*Repeat+int(eye_offset*samp_rate)
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 7*Repeat+int(eye_offset*samp_rate)
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: int(eye_offset*samp_rate)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*3.14*frequency_spread/sensitivity
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: Repeat
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: PacketSize
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: sensitivity
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: TX1
    bb_gain0: '40'
    bw0: 300e3
    freq0: carrier_freq
    gain0: '30'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 50e3
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-200'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    nconnections: '8'
    size: int(2*Repeat)
    srate: samp_rate
    type: float
    update_time: '.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '''unpacked_data'''
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '''TimeBits'''
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '''unpacked_data'''
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '''TimeBits'''
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_c_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0_0_0, '5']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_0_0_0, '4']
- [blocks_delay_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_delay_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '3']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '6']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '7']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_vco_c_0, '0', osmosdr_sink_0, '0']
- [blocks_vco_c_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_vco_c_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', virtual_sink_1, '0']
- [virtual_source_1, '0', blocks_delay_0, '0']
- [virtual_source_1, '0', blocks_delay_0_0, '0']
- [virtual_source_1, '0', blocks_delay_0_0_0, '0']
- [virtual_source_1, '0', blocks_delay_0_0_0_0, '0']
- [virtual_source_1, '0', blocks_delay_0_0_0_0_0, '0']
- [virtual_source_1, '0', blocks_delay_0_0_0_0_0_0_0_0_0_0, '0']
- [virtual_source_1, '0', blocks_delay_0_0_0_0_0_0_0_0_0_0_0, '0']
- [virtual_source_1, '0', blocks_delay_0_1, '0']

metadata:
  file_format: 1
